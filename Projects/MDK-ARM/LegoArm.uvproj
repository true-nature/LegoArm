# Keil uVision project LegoArm.uvproj, settings and files
target LegoArm Configuration (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
				FPU2
  output: LegoArm Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99  --fpu=vfpv2
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ; ..\..\Drivers\CMSIS\Include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Inc; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ; ..\..\Drivers\CMSIS\Include
  asm include: ..\..\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: gpio.c i2c.c main.c spi.c stm32f3xx_it.c tim.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c freertos.c command.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
    ../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/: startup_stm32f303xc.s
  group Drivers/STM32F3xx_HAL_Driver
    ../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
